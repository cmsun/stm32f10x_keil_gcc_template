# Keil uVision project template.uvprojx, settings and files
target template (ARM-GNU)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template
  group scmlib
    ./scmf10xlib/: Sm_GPIO.cpp Sm_Delay.cpp Sm_SysTick.cpp Sm_Debug.cpp Sm_TIM1.cpp Sm_TIM2.cpp Sm_TIM3.cpp Sm_TIM4.cpp Sm_TIM5.cpp Sm_TIM6.cpp Sm_TIM7.cpp Sm_TIM8.cpp Sm_Pluse.cpp Sm_USART1.cpp
  group cmsis
    ./cmsis/GNU/: core_cm3.c system_stm32f10x.c
  group StdPeriphDriver
    ./StdPeriphDriver/v3.5/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ./user/: motion.cpp
  group newlib
    ./newlib/: _exit.c _sbrk.c _syscalls.c assert.c _startup.c
  group ucosiii
    ./UCOSIII/Boards/STM32F103/GNU/BSP/: bsp.c
    ./UCOSIII/Boards/STM32F103/GNU/Cfg/: os_app_hooks.c
    ./UCOSIII/Boards/STM32F103/GNU/Ports/: cpu_c.c os_cpu_c.c cpu_a.s lib_mem_a.s os_cpu_a.s
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uCOS-III/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group cortexm
    ./cmsis/GNU/cortexm/: _initialize_hardware.c _reset_hardware.c exception_handlers.c vectors_stm32f10x.c
